## config/boards/shields/LegPad/Kconfig.defconfig
```kconfig
if SHIELD_LEGPAD

    config ZMK_KEYBOARD_NAME
        default "LegPad"

    endif
```
